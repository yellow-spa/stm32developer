# Keil uVision project stm32developer.uvprojx, settings and files
target stm32developer (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32developer +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\FWLib\inc;..\..\Libraries\Core;..\..\include;..\..\Libraries;..\..\hardware\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group init
    ../../init/: main.c
  group include
    ../../include/: bluetooth.h gpio.h led.h usart.h timer.h pwm.h tftlcd.h i2c2.h i2c-core.h sensors.h HMC5883L.h MPU6050.h
    ../../hardware/include/: ATKPackage.h stabilizer_types.h sensors_types.h
  group drivers
    ../../drivers/leds/: led-core.c leds-gpio.c
    ../../drivers/i2c/: i2c-core.c i2c-gpio.c
    ../../drivers/systick/: systick.c
    ../../drivers/gpio/: gpio-common.c
    ../../drivers/usart/: usart-gpio.c usart-core.c
    ../../drivers/bluetooth/HC05/: bluetooth-core.c bluetooth-gpio.c
    ../../drivers/pwm/: pwm.c
    ../../drivers/timer/: timer-core.c
    ../../drivers/LCD/TFT/: tftlcd-config.c tftlcd-core.c
    ../../drivers/sensors/: sensors.c
  group Libraries
    ../../Libraries/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../Libraries/Core/: core_cm3.c
    ../../Libraries/startup/: startup_stm32f10x_hd.s
    ../../Libraries/: stm32f10x_it.c system_stm32f10x.c
  group hardware
    ../../hardware/: pwm-led.c ATKPackage.c tftlcd_hardware.c
